# IAR project urea.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\CMSIS; ..\include; ..\Libraries\inc; ..\User; ..\Drivers\include; ..\interface
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: urea.srec
  ILINK.IlinkOutputFile: urea.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIC
    ../CMSIS/: system_stm32f10x.c
  group Drivers/include
    ../Drivers/include/: sws_ad7799.h
  group Drivers/source
    ../Drivers/source/: sws_ad7799.c
  group interface
    ../interface/: sws_adc.h
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group User
    ../User/: AD7799.c esp8266.c flash.c main.c sim300.c stm32f10x_it.c swsbus.c
  group User/sws_usrcfg
    ../User/sws_usrcfg/: sws_usrcfg.c
